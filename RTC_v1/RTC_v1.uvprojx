# Keil uVision project RTC_v1.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RTC_v1
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=C:\Users\Viethuong_Nguyen\OneDrive\LastYear\Embeded\Projects\RTC_v1\Objects\viethuong.bin C:\Users\Viethuong_Nguyen\OneDrive\LastYear\Embeded\Projects\RTC_v1\Objects\RTC_v1.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: RTC.c sw.c sw.h main.c Led.c Led.h SLCD.c mode.c Systick.c Systick.h
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
